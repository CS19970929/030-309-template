# Keil uVision project CommomSH367309_16series_030C8T6_C.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: CommomSH367309_16series_030C8T6_C
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c misc: --C99
  c include: .\Code\Drivers;.\Code\STM32F0xx_StdPeriph_Driver\inc;.\Code\Source\NewFunc;.\Code\Source;.\Code\Source\conf;.\Code\Source\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8001c00 size 0xc400
  memory RVCT9: RAM 0x200000c0 size 0x1f40
  group Drivers
    ./Code/Drivers/: core_cm0.h core_cmFunc.h core_cmInstr.h startup_stm32f0xx.s stm32f0xx.h stm32f0xx_conf.h stm32f0xx_it.c stm32f0xx_it.h system_stm32f0xx.c system_stm32f0xx.h
  group Source
    ./Code/Source/: ADC.c Cell_balance.c ChargerLoadFunc.c DataDeal.c EEPROM.c Fault.c Flash.c Heat_Cool.c I2C_AFE1.c I2C_Slave.c main.c ProductionID.c PubFunc.c PWM.c RTC.c Sci_Upper.c SH367309_DataDeal.c SH367309_Func.c SleepDeal.c SOC.c System_Init.c System_Monitor.c Uart_Client.c IO_Control.c IODrivers.c ShortFunc.c SocEnhance.c led_soc.c FlashEEPROM.c LogRecord_flash.c log_test.c
  group STM32F0xx_StdPeriph_Driver
    ./Code/STM32F0xx_StdPeriph_Driver/inc/: stm32f0xx_adc.h stm32f0xx_can.h stm32f0xx_cec.h stm32f0xx_comp.h stm32f0xx_crc.h stm32f0xx_crs.h stm32f0xx_dac.h stm32f0xx_dbgmcu.h stm32f0xx_dma.h stm32f0xx_exti.h stm32f0xx_flash.h stm32f0xx_gpio.h stm32f0xx_i2c.h stm32f0xx_iwdg.h stm32f0xx_misc.h stm32f0xx_pwr.h stm32f0xx_rcc.h stm32f0xx_rtc.h stm32f0xx_spi.h stm32f0xx_syscfg.h stm32f0xx_tim.h stm32f0xx_usart.h stm32f0xx_wwdg.h
    ./Code/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group conf
    ./Code/Source/conf/: conf.c conf.h conf_gpio.h
  group bsp
    ./Code/Source/BSP/: param.c bsp.c bsp_cpu_flash.c
